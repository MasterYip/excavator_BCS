# Keil uVision project Excavator.uvprojx, settings and files
target Excavator (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Excavator +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --cpp11
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../HARDWARE/MPU6050_IIC_Hardware;../HARDWARE/MotorCtrl;../HARDWARE/sys;../HARDWARE/delay;../HARDWARE/usart;../HARDWARE;../MDK-ARM;../Libraries;../Libraries/ANO_Client;../Libraries/RobotArm;../Libraries/rosserial_stm32;../Libraries/rosserial_stm32/ros;../Libraries/ROS_Communication;../HARDWARE/ICM20602
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group HardWare/MotorCtrl
    ../HARDWARE/MotorCtrl/: abstract_layer.c control_layer.c CtrlLib_settings.c drive_layer.c quantization_layer.c readme.txt CtrlLib_settings.h
  group HardWare/ICM20602
    ../HARDWARE/ICM20602/: filter.c mahony_filter.c SEEKFREE_ICM20602.c
  group System
    ../HARDWARE/sys/: sys.c
    ../HARDWARE/delay/: delay.c
  group Libraries
    ../Libraries/ANO_Client/: ano_client.c
    ../Libraries/RobotArm/: RobotArm.c
  group GlobalSettings
    ../Libraries/: ExcavatorSettings.c ExcavatorHeaderFile.h
  group ROSSerial
    ../Libraries/rosserial_stm32/: duration.cpp ros.h STM32Hardware.h time.cpp
    ../Libraries/rosserial_stm32/ros/: duration.h msg.h node_handle.h publisher.h service_client.h service_server.h subscriber.h time.h
  group ROS_Communication
    ../Libraries/ROS_Communication/: uart_node.c
